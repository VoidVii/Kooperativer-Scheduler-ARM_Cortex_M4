# IAR project Learning_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1233H6PM TexasInstruments TM4C1233H6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Learning_1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group dbg
    ./: Clock.c Clock.h Coop_Scheduler.c Coop_Scheduler.h Debounce_Switch.c Debounce_Switch.h delay_ms.c delay_ms.h GPIO.c GPIO.h LED.c LED.h main.c SysTick.c SysTick.h Tm4c123gh6pm_Init.c Tm4c123gh6pm_Init.h
  group TivaBoard
    ./: tm4c123gh6pm.h
